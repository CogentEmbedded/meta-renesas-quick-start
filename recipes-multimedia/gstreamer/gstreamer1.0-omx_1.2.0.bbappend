FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-{PV}:"

#SRC_URI_append = " 
#    file://0001-Add-export-buffer-feature-support.patch 
#"

PR="r1"

