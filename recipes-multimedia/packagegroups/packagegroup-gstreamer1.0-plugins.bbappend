RDEPENDS_packagegroup-gstreamer1.0-plugins-base_append = " gstreamer1.0-plugins-base-app \
"
RDEPENDS_packagegroup-gstreamer1.0-plugins-video_append = " gstreamer1.0-plugins-good-imagefreeze \
"