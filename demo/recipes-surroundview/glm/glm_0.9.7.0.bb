require glm.inc

SRC_URI = "\
	https://github.com/g-truc/${BPN}/archive/${PV}.tar.gz \
	file://0001-Fix-cmake-pathes.patch \
"

SRC_URI[md5sum] = "33025d322f08e7783f6513272ef60aff"
SRC_URI[sha256sum] = "71f95cb20602dff9e799e7f4854d4173474382dbd9d0efc6f77bde6d289351fa"

