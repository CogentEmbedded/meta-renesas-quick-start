IMAGE_INSTALL_append = " \
	packagegroup-common \
	packagegroup-qt \
	packagegroup-opencv \
	packagegroup-surroundview \
"

DISTRO_FEATURES_remove = "x11"
