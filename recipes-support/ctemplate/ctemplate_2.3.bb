require ctemplate.inc

SRC_URI = "svn://ctemplate.googlecode.com/svn/;module=tags/ctemplate-2.3;protocol=http"
SRC_URI[md5sum] = ""
SRC_URI[sha256sum] = ""
SRCREV = "r141"
S = "${WORKDIR}/tags/ctemplate-2.3"
B = "${WORKDIR}/tags/ctemplate-2.3"

