require ${PN}.inc

SRC_URI = "git://github.com/stevengj/${BPN}.git"
S = "${WORKDIR}/git"
SRCREV = "cc413c5491df015c93992ddedd43b222d4369b45"

DEFAULT_PREFERENCE = "-1"

