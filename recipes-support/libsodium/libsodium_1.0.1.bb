require libsodium.inc

SRC_URI[md5sum]    = "9a221b49fba7281ceaaf5e278d0f4430"
SRC_URI[sha256sum] = "c3090887a4ef9e2d63af1c1e77f5d5a0656fadb5105ebb9fb66a302210cb3af5"

S = "${WORKDIR}/${PN}-${PV}"

