require ${BPN}.inc

SRC_URI = "git://github.com/analogdevicesinc/${BPN}.git"
S = "${WORKDIR}/git"
SRCREV = "7ce5cd5b508389077aedaaa4d5f1c0b08b78ded5"

DEFAULT_PREFERENCE = "1"

