require libplist.inc

SRC_URI = "git://github.com/libimobiledevice/libplist.git"

SRCREV = "9ca25d293fe7f8aca8d952fc7bb91464fe2d34ab"
S = "${WORKDIR}/git"

PV = "1.12+git${SRCREV}"
