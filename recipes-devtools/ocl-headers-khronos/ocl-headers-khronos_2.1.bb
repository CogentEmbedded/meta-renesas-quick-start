require ${BPN}.inc

DEFAULT_PREFERENCE = "-2"