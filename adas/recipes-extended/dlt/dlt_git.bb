require ${BPN}.inc

SRCREV = "7f3b861410374effbba07ad71c1f1af7d922b713"

PV = "git+${SRCREV}"

DEFAULT_PREFERENCE = "-1"
