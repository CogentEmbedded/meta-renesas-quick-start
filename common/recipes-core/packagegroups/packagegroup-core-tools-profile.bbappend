# add flamegraph for parsing profiling results
RRECOMMENDS_${PN}_append = " flamegraph"
