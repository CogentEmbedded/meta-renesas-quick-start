RDEPENDS_${PN} += " \
    packagegroup-common \
    packagegroup-opencv-sdk \
    packagegroup-ptp \
    packagegroup-perf-test \
"
