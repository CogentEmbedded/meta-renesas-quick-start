require ${BPN}.inc

SRC_URI = "https://forge.imag.fr/frs/download.php/698/${BPN}-${PV}.tar.gz"
SRC_URI[md5sum] = "5e2f68589eae486491482821c0f5879c"
SRC_URI[sha256sum] = "25360a62a80558f3128164510b53ee00713a54db45de2faa1b6f4bd28191a184"


