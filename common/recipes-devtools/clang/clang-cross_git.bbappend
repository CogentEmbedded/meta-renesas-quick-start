
# Backport the recipe to old naming scheme
DEPENDS_remove = "binutils-cross-arm"
DEPENDS += "binutils-cross"
