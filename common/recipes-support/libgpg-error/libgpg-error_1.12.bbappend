# make compilation with GCC 5 possible
BUILD_CPPFLAGS_append_class-native = " -P"
BUILD_CPPFLAGS_append_class-nativesdk = " -P"
