require libusbg.inc

PV = "0.1.0b"
SRCREV = "f1613aab97513188478087e001defbfca6847eca"
SRC_URI = "git://github.com/kopasiak/libusbg.git"

S = "${WORKDIR}/git"

DEFAULT_PREFERENCE = "1"
