TOOLCHAIN_HOST_TASK += "nativesdk-packagegroup-weston-toolchain-host"
TOOLCHAIN_TARGET_TASK += "packagegroup-weston-toolchain-target"

